# Keil uVision project REMOTE.uvprojx, settings and files
target REMOTE (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: REMOTE +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\REMOTE;..\FWLIB\inc;..\HARDWARE\PWM;..\HARDWARE\Control;..\HARDWARE\KEY;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\HC05;..\HARDWARE\CAN
  asm include: ..\HARDWARE\CAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c motor.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Control/: control.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_can.c
  group README
    ../: readme.txt
